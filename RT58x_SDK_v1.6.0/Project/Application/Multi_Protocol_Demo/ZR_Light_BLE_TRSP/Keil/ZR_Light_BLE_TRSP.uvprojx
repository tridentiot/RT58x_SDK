# Keil uVision project ZR_Light_BLE_TRSP.uvprojx, settings and files
target RT581 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ZR_Light_BLE_TRSP +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --elf --output=@L.elf #L
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CHIP_VERSION = RT58X_MPB, BOARD=A048
  c include: ..\config;..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\RT58x\Peripheral\Include;..\..\..\..\..\Library\RT58x\PHY\include;..\..\..\..\..\Library\RT58x\include;..\..\..\..\..\Middleware\Portable\Utility\Include;..\..\..\..\..\Middleware\Portable\System\Include;..\Keil;..\..\..\..\..\Middleware\Portable\bsp\Include;..\..\..\..\..\Middleware\MemoryMgmt\Include;..\..\..\..\..\Middleware\RFB\include;..\..\..\..\..\Library\RT58x\PHY\rt569mp\include;..\..\..\..\..\Middleware\RUCI\include;..\include;..\..\..\..\..\Middleware\RF_FW_Control_Task\Include;..\..\..\..\..\Library\RT58x\Device\Include;..\..\..\..\..\Middleware\Portable\Micro_Filesystem\Include;..\..\..\..\..\Middleware\Zigbee\Include;..\..\..\..\..\Middleware\Zigbee\Include\osif;..\..\..\..\..\Middleware\Zigbee\Include\ZCL;..\..\..\..\..\Middleware\BLE\Portable\Include;..\..\..\..\..\Middleware\BLE\BLE_Host\Include;..\..\..\..\..\Middleware\BLE\BLE_Service\BLE_Service_Common\Include;..\..\..\..\..\Middleware\BLE\BLE_Service\GAPS\Include;..\..\..\..\..\Middleware\BLE\BLE_Service\DIS\Include;..\..\..\..\..\Middleware\BLE\BLE_Service\GATTS\Include;..\..\..\..\..\Middleware\BLE\BLE_Service\TRSPS\Include;..\..\..\..\..\Middleware\BLE\BLE_Service\FOTAS\Include;..\..\..\..\..\Middleware\FOTA\Include;..\Zigbee_App\Include;..\BLE_App_Profile\Include;..\..\..\..\..\Library\RT58x\Crypto\include
  asm define: USE_FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT5: ROM 0x51000 size 0x190
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ZR_Light_BLE_TRSP.sct
  group Application
    ../: main.c multi_app.c
  group Application_BLE
    ../BLE_App_Profile/: ble_profile_app.c ble_profile_def.c ble_app.c
  group Application_Zigbee
    ../Zigbee_App/: zigbee_zcl_msg_handler.c
    ../Zigbee_App//: zigbee_evt_handler.c zigbee_data.c zigbee_app.c
  group Startup
    ../../../../../Library/RT58x/Device/: system_cm3_mcu.c
    ../../../../../Library/RT58x/Device/ARM/: startup_cm3_mcu.s
  group Library
    ../../../../../Library/RT58x/Peripheral/: gpio.c sysctrl.c sysfun.c timer.c dma.c uart_drv.c uart_retarget.c flashctl.c mp_sector.c pwm.c lpm.c sadc.c
    ../../../../../Library/RT58x/Crypto/: aes.c crypto.c crypto_util.c
  group FreeRTOS
    ../../../../../Middleware/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c timers.c
    ../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../config/: FreeRTOSConfig.h
  group System
    ../../../../../Middleware/Portable/System/: sys_arch.c sys_memory.c sys_taskdbg.c sys_timer.c
  group Utility
    ../../../../../Middleware/Portable/Utility/: util.c util_list.c shell.c util_printf.c util_string.c util_log.c util_queue.c util_bstream.c util_bda.c util_fcs.c fsm.c
  group CLI
    ../CLI/: cli_cmd_rd.c cli_cmd_sys.c cli_cosole.c
  group ZigBee
    ../../../../../Middleware/Prebuild/: lib_zigbee_stack.lib
    ../../../../../Middleware/Zigbee/: zigbee_lib_api.c
  group BSP
    ../../../../../Middleware/Portable/bsp/: bsp.c bsp_button.c bsp_console.c bsp_led.c bsp_uart.c
  group MemMgmt
    ../../../../../Middleware/MemoryMgmt/: mem_mgmt.c
  group mfs
    ../../../../../Middleware/Portable/Micro_Filesystem/src/: crc.c mfs.c
  group Phy
    ../../../../../Library/RT58x/PHY/rt569mp/: rt569mp_init.c rt569mp_fw.c
    ../../../../../Library/RT58x/PHY/: rf_tx_comp.c
  group Multi_Protocol
    ../../../../../Middleware/Prebuild/: lib_dual_task.lib
  group BLE_Host
    ../../../../../Middleware/Prebuild/: lib_ble_host.lib
    ../../../../../Middleware/BLE/BLE_Host/: ble_host_ref.c ble_cmd_advertising.c ble_cmd_att_gatt.c ble_cmd_common.c ble_cmd_gap.c ble_cmd_scan.c ble_cmd_security_manager.c
  group BLE_Service
    ../../../../../Middleware/BLE/BLE_Service/BLE_Service_Common/: ble_service_common.c
    ../../../../../Middleware/BLE/BLE_Service/GAPS/: ble_service_gaps.c
    ../../../../../Middleware/BLE/BLE_Service/TRSPS/: ble_service_trsps.c
    ../../../../../Middleware/BLE/BLE_Service/GATTS/: ble_service_gatts.c
    ../../../../../Middleware/BLE/BLE_Service/DIS/: ble_service_dis.c
    ../../../../../Middleware/BLE/BLE_Service/FOTAS/: ble_service_fotas.c
  group BLE_FOTA
    ../../../../../Middleware/FOTA/: ble_fota.c
software components: CMSIS:CORE 5.0.1

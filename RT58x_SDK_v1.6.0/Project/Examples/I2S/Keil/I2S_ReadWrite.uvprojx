# Keil uVision project I2S_ReadWrite.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: I2S_ReadWrite +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\config;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\RT58x\Peripheral\Include;..\..\..\..\Library\RT58x\PHY\include;..\..\..\..\Library\RT58x\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../: main.c
  group Startup
    ../../../../Library/RT58x/Device/: system_cm3_mcu.c
    ../../../../Library/RT58x/Device/ARM/: startup_cm3_mcu.s
  group Library
    ../../../../Library/RT58x/Peripheral/: retarget_drv_keil.c dma.c i2c_master.c i2s.c timer.c sysfun.c sysctrl.c gpio.c uart_drv.c flashctl.c mp_sector.c
    ../../../../Middleware/Prebuild/: lib_rf_mcu.lib
software components: CMSIS:CORE 5.0.1

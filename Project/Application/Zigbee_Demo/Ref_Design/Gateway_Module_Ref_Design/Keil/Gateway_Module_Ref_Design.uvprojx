# Keil uVision project Gateway_Module_Ref_Design.uvprojx, settings and files
target Gateway_Module_Ref_Design (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Gateway_Module_Ref_Design +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BOARD=A048
  c include: ..\config;..\..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\Library\RT58x\Peripheral\Include;..\..\..\..\..\..\Library\RT58x\PHY\include;..\..\..\..\..\..\Library\RT58x\Include;..\..\..\..\..\..\Middleware\Portable\Utility\include;..\..\..\..\..\..\Middleware\Portable\System\Include;..\Keil;..\..\..\..\..\..\Middleware\Portable\bsp_for_ref_design\bsp_for_Gateway_Module_Ref_Design\Include;..\..\..\..\..\..\Middleware\MemoryMgmt\Include;..\..\..\..\..\..\Middleware\Zigbee\Include;..\..\..\..\..\..\Middleware\RFB\include;..\..\..\..\..\..\Library\RT58x\PHY\rt569mp\include;..\..\..\..\..\..\Middleware\RUCI\include;..\include;..\..\..\..\..\..\Middleware\RF_FW_Control_Task\Include;..\..\..\..\..\..\Library\RT58x\Device\Include;..\..\..\..\..\..\Middleware\Portable\Micro_Filesystem\include;..\..\..\..\..\..\Middleware\Zigbee\Include\osif;..\..\..\..\..\..\Middleware\Zigbee\Include\ZCL;..\..\..\..\..\..\Library\RT58x\Crypto\include
  asm define: USE_FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT5: ROM 0x51000 size 0x190
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Gateway_Module_Ref_Design.sct
  group Application
    ../: main.c zigbee_app.c zigbee_data.c zigbee_evt_handler.c zigbee_zcl_msg_handler.c uart_handler.c zigbee_gateway_cmd_handle.c raf_cmd_cfm_handle.c zigbee_gateway_cmd_app_service.c
  group Startup
    ../../../../../../Library/RT58x/Device/: system_cm3_mcu.c
    ../../../../../../Library/RT58x/Device/ARM/: startup_cm3_mcu.s
  group Library
    ../../../../../../Library/RT58x/Peripheral/: gpio.c sysctrl.c sysfun.c timer.c dma.c uart_retarget.c flashctl.c mp_sector.c lpm.c sadc.c
    ../../../../../../Library/RT58x/PHY/rt569mp/: rt569mp_fw.c rt569mp_init.c
    ../../../../../../Library/RT58x/PHY/: rf_tx_comp.c
    ../../../../../../Library/RT58x/Crypto/: aes.c crypto.c crypto_util.c
  group FreeRTOS
    ../../../../../../Middleware/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c timers.c
    ../../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../config/: FreeRTOSConfig.h
  group System
    ../../../../../../Middleware/Portable/System/: sys_arch.c sys_taskdbg.c sys_timer.c
  group Utility
    ../../../../../../Middleware/Portable/Utility/: util.c util_list.c shell.c util_printf.c util_string.c util_log.c util_queue.c util_bstream.c util_bda.c util_fcs.c fsm.c
  group CLI
    ../CLI/: cli_cmd_rd.c cli_cmd_sys.c cli_cosole.c cli_cmd_gateway.c
  group ZigBee
    ../../../../../../Middleware/Prebuild/: lib_zigbee_stack.lib lib_pci_task.lib
    ../../../../../../Middleware/Zigbee/: zigbee_lib_api.c
  group Portable_bps
    ../../../../../../Middleware/Portable/bsp_for_ref_design/bsp_for_Gateway_Module_Ref_Design/: bsp.c bsp_button.c bsp_console.c bsp_led.c bsp_uart.c bsp_uart_drv.c
  group MemMgmt
    ../../../../../../Middleware/MemoryMgmt/: mem_mgmt.c
  group mfs
    ../../../../../../Middleware/Portable/Micro_Filesystem/src/: mfs.c crc.c
software components: CMSIS:CORE 5.0.1

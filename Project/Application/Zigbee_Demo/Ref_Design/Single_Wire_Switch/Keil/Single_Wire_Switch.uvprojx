# Keil uVision project Single_Wire_Switch.uvprojx, settings and files
target RT581 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Single_Wire_Switch +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --elf --output=@L.elf #L
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD=A048
  c include: ..\config;..\..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\Library\RT58x\Peripheral\Include;..\..\..\..\..\..\Library\RT58x\PHY\include;..\..\..\..\..\..\Library\RT58x\include;..\..\..\..\..\..\Middleware\Portable\Utility\Include;..\..\..\..\..\..\Middleware\Portable\System\Include;..\Keil;..\..\..\..\..\..\Middleware\Portable\bsp_for_ref_design\bsp_for_Single_Wire_Switch\Include;..\..\..\..\..\..\Middleware\MemoryMgmt\Include;..\..\..\..\..\..\Middleware\RFB\include;..\..\..\..\..\..\Library\RT58x\PHY\rt569mp\include;..\..\..\..\..\..\Middleware\RUCI\include;..\include;..\..\..\..\..\..\Middleware\RF_FW_Control_Task\Include;..\..\..\..\..\..\Library\RT58x\Device\Include;..\..\..\..\..\..\Middleware\Portable\Micro_Filesystem\Include;..\..\..\..\..\..\Middleware\Zigbee\Include;..\..\..\..\..\..\Middleware\Zigbee\Include\osif;..\..\..\..\..\..\Middleware\Zigbee\Include\ZCL_for_ref_design\ZCL_for_Single_Wire_Switch;..\..\..\..\..\..\Library\RT58x\Crypto\include;..\..\..\..\..\..\Middleware\FOTA\Include
  asm define: USE_FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT5: ROM 0x51000 size 0x190
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Single_Wire_Switch.sct
  group Application
    ../: main.c zigbee_app.c zigbee_data.c zigbee_evt_handler.c zigbee_zcl_msg_handler.c
  group Startup
    ../../../../../../Library/RT58x/Device/: system_cm3_mcu.c
    ../../../../../../Library/RT58x/Device/ARM/: startup_cm3_mcu.s
  group Library
    ../../../../../../Library/RT58x/Peripheral/: gpio.c sysctrl.c sysfun.c timer.c dma.c uart_drv.c uart_retarget.c flashctl.c mp_sector.c pwm.c lpm.c sadc.c
    ../../../../../../Library/RT58x/PHY/rt569mp/: rt569mp_fw.c rt569mp_init.c
    ../../../../../../Library/RT58x/PHY/: rf_tx_comp.c
    ../../../../../../Library/RT58x/Crypto/: aes.c crypto.c crypto_util.c
  group FreeRTOS
    ../../../../../../Middleware/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c timers.c
    ../../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../config/: FreeRTOSConfig.h
  group System
    ../../../../../../Middleware/Portable/System/: sys_arch.c sys_memory.c sys_taskdbg.c sys_timer.c
  group Utility
    ../../../../../../Middleware/Portable/Utility/: util.c util_list.c shell.c util_printf.c util_string.c util_log.c util_queue.c util_bstream.c util_bda.c util_fcs.c fsm.c
  group CLI
    ../CLI/: cli_cmd_rd.c cli_cmd_sys.c cli_cosole.c
  group ZigBee
    ../../../../../../Middleware/Prebuild/: lib_pci_task.lib lib_zigbee_stack_ed.lib
    ../../../../../../Middleware/Zigbee/: zigbee_lib_api.c
  group BSP
    ../../../../../../Middleware/Portable/bsp_for_ref_design/bsp_for_Single_Wire_Switch/: bsp.c bsp_button.c bsp_console.c bsp_led.c bsp_uart.c
  group MemMgmt
    ../../../../../../Middleware/MemoryMgmt/: mem_mgmt.c
  group mfs
    ../../../../../../Middleware/Portable/Micro_Filesystem/src/: crc.c mfs.c
software components: CMSIS:CORE 5.0.1

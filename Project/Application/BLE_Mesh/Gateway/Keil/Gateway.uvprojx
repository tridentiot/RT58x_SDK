# Keil uVision project Gateway.uvprojx, settings and files
target RT58x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Gateway +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\config;..\Keil;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\RT58x\Peripheral\Include;..\..\..\..\..\Library\RT58x\PHY\Include;..\..\..\..\..\Library\RT58x\PHY\rt569mp\include;..\..\..\..\..\Library\RT58x\include;..\..\..\..\..\Library\RT58x\CRYPTO\include;..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\Middleware\Portable\Utility\Include;..\..\..\..\..\Middleware\Portable\System\Include;..\..\..\..\..\Middleware\Portable\Platform\RT58x\Include;..\..\..\..\..\Middleware\Portable\bsp\Include;..\..\..\..\..\Middleware\RF_FW_Control_Task\Include;..\..\..\..\..\Middleware\BLE\BLE_Host\Include;..\..\..\..\..\Middleware\BLE\BLE_Service\BLE_Service_Common\Include;..\..\..\..\..\Middleware\BLE\BLE_Service\FOTAS\Include;..\..\..\..\..\Middleware\BLE\BLE_Service\Mesh_Proxy\Include;..\..\..\..\..\Middleware\BLE\BLE_Service\Mesh_Prov\Include;..\..\..\..\..\Middleware\BLE\BLE_Service\TRSPS\Include;..\..\..\..\..\Middleware\BLE_Mesh\model\common\include;..\..\..\..\..\Middleware\BLE_Mesh\Model\Generics\Include;..\..\..\..\..\Middleware\BLE_Mesh\BLE_App_Profile;..\..\..\..\..\Middleware\BLE_Mesh\Include;..\..\..\..\..\Middleware\FOTA\Include;..\..\..\..\..\Middleware\MemoryMgmt\Include;..\include
  asm define: USE_FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT5: ROM 0x51000 size 0x190
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Gateway.sct
  group Application
    ../: main.c ble_mesh_gateway_cmd_handle.c uart_handler.c mesh_app.c
  group Startup
    ../../../../../Library/RT58x/Device/: system_cm3_mcu.c
    ../../../../../Library/RT58x/Device/ARM/: startup_cm3_mcu.s
  group Library
    ../../../../../Library/RT58x/CRYPTO/: aes.c crypto.c
    ../../../../../Library/RT58x/Peripheral/: gpio.c sysctrl.c sysfun.c timer.c dma.c flashctl.c uart_retarget.c lpm.c mp_sector.c sadc.c rtc.c flashds.c
    ../../../../../Library/RT58x/Crypto/: crypto_util.c
  group FreeRTOS
    ../../../../../Middleware/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c timers.c
    ../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../config/: FreeRTOSConfig.h
  group System
    ../../../../../Middleware/Portable/System/: sys_arch.c sys_memory.c sys_printf.c sys_taskdbg.c sys_timer.c
  group Utility
    ../../../../../Middleware/Portable/Utility/: util.c util_list.c shell.c util_printf.c util_string.c util_log.c util_queue.c util_bstream.c util_bda.c util_fcs.c fsm.c
  group Phy
    ../../../../../Middleware/Prebuild/: lib_rf_mcu.lib
    ../../../../../Library/RT58x/PHY/: rf_tx_comp.c
    ../../../../../Library/RT58x/PHY/rt569mp/: rt569mp_fw.c rt569mp_init.c
  group BSP
    ../../../../../Middleware/Portable/bsp/: bsp.c bsp_button.c bsp_console.c bsp_led.c bsp_uart.c bsp_uart_drv.c
  group Model
    ../../../../../Middleware/BLE_Mesh/model/common/: mmdl_client.c
  group BLE_FOTA
    ../../../../../Middleware/FOTA/: ble_fota.c
  group BLE_Mesh
    ../../../../../Middleware/Prebuild/: lib_ble_hci_task.lib lib_ble_host.lib lib_ble_mesh_cl.lib
    ../../../../../Middleware/BLE_Mesh/: ble_mesh_lib_api.c
  group CLI
    ../CLI/: cli_cmd_gateway.c cli_cmd_sys.c cli_cosole.c
  group BLE_Service
    ../../../../../Middleware/BLE/BLE_Service/BLE_Service_Common/: ble_service_common.c
    ../../../../../Middleware/BLE/BLE_Service/Mesh_Prov/: ble_service_mesh_prov.c
    ../../../../../Middleware/BLE/BLE_Service/Mesh_Proxy/: ble_service_mesh_proxy.c
    ../../../../../Middleware/BLE/BLE_Service/TRSPS/: ble_service_trsps.c
    ../../../../../Middleware/BLE/BLE_Service/FOTAS/: ble_service_fotas.c
software components: CMSIS:CORE 5.0.1

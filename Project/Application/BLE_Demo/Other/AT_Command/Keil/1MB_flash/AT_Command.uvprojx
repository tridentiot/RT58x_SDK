# Keil uVision project AT_Command.uvprojx, settings and files
target RT58x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: AT_Command +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CHIP_TYPE=RT581, CHIP_VERSION=RT58X_MPB, RF_FW_INCLUDE_BLE=TRUE, RF_FW_INCLUDE_PCI=FALSE, RF_FW_INCLUDE_MULTI_2P4G=FALSE, SUPPORT_BLE
  c include: ..\..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\..\Library\RT58x\Peripheral\Include;..\..\..\..\..\..\..\Library\RT58x\PHY\include;..\..\..\..\..\..\..\Library\RT58x\include;..\..\..\..\..\..\..\Library\RT58x\PHY\rt569mp\include;..\..\..\..\..\..\..\Middleware\RF_FW_Control_Task\Include;..\..\..\..\..\..\..\Middleware\RUCI\include;..\..\..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\..\..\Middleware\Portable\Utility\include;..\..\..\..\..\..\..\Middleware\Portable\System\Include;..\..\..\..\..\..\..\Middleware\Portable\bsp\Include;..\..\..\..\..\..\..\Middleware\MemoryMgmt\Include;..\..\..\..\..\..\..\Middleware\BLE\BLE_Host\Include;..\..\..\..\..\..\..\Middleware\FOTA\Include;..\..\..\..\..\..\..\Middleware\BLE\BLE_Service\BLE_Service_Common\Include;..\..\..\..\..\..\..\Middleware\BLE\BLE_Service\GAPS\Include;..\..\..\..\..\..\..\Middleware\BLE\BLE_Service\DIS\Include;..\..\..\..\..\..\..\Middleware\BLE\BLE_Service\GATTS\Include;..\..\..\..\..\..\..\Middleware\BLE\BLE_Service\TRSPS\Include;..\..\BLE_App_Profile\Include;..\..\Include;..\..\Config;..\..\Keil;..\..\BLE_ATCMD\Include;..\..\BLE_ATCMD
  asm define: USE_FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\AT_Command.sct
  group Application
    ../../: main.c ble_app.c
    ../../BLE_App_Profile/: ble_profile_def.c ble_profile_app.c
    ../../config/: project_config.h
  group Startup
    ../../../../../../../Library/RT58x/Device/: system_cm3_mcu.c
    ../../../../../../../Library/RT58x/Device/ARM/: startup_cm3_mcu.s
  group Library
    ../../../../../../../Library/RT58x/Peripheral/: gpio.c sysctrl.c sysfun.c timer.c dma.c flashctl.c uart_drv.c uart_retarget.c lpm.c mp_sector.c sadc.c
  group FreeRTOS
    ../../../../../../../Middleware/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c timers.c
    ../../../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../Config/: FreeRTOSConfig.h
  group System
    ../../../../../../../Middleware/Portable/System/: sys_arch.c sys_memory.c sys_printf.c sys_taskdbg.c sys_timer.c
  group Utility
    ../../../../../../../Middleware/Portable/Utility/: util.c util_list.c util_printf.c util_string.c util_log.c shell.c util_bda.c util_bstream.c util_fcs.c util_queue.c
  group BSP
    ../../../../../../../Middleware/Portable/bsp/: bsp.c bsp_button.c bsp_console.c bsp_led.c bsp_uart.c
  group MemMgmt
    ../../../../../../../Middleware/MemoryMgmt/: mem_mgmt.c
  group Phy
    ../../../../../../../Middleware/Prebuild/: lib_rf_mcu.lib
    ../../../../../../../Library/RT58x/PHY/: rf_tx_comp.c
    ../../../../../../../Library/RT58x/PHY/rt569mp/: rt569mp_fw.c rt569mp_init.c
  group BLE_Host
    ../../../../../../../Middleware/Prebuild/: lib_ble_host.lib lib_ble_hci_task.lib
    ../../../../../../../Middleware/BLE/BLE_Host/: ble_host_ref.c ble_cmd_advertising.c ble_cmd_att_gatt.c ble_cmd_common.c ble_cmd_gap.c ble_cmd_scan.c ble_cmd_security_manager.c ble_cmd_privacy.c
  group BLE_Service
    ../../../../../../../Middleware/BLE/BLE_Service/Ble_Service_Common/: ble_service_common.c
    ../../../../../../../Middleware/BLE/BLE_Service/GAPS/: ble_service_gaps.c
    ../../../../../../../Middleware/BLE/BLE_Service/GATTS/: ble_service_gatts.c
    ../../../../../../../Middleware/BLE/BLE_Service/DIS/: ble_service_dis.c
    ../../../../../../../Middleware/BLE/BLE_Service/TRSPS/: ble_service_trsps.c
  group AT_CMD
    ../../BLE_ATCMD/: atcmd.c
    ../../BLE_ATCMD/Source/: atcmd_command.c atcmd_command_list.c atcmd_helper.c atcmd_init.c atcmd_parser.c atcmd_queue.c
  group AT_CMD_List
    ../../BLE_ATCMD/Source/Command/Common/Address/: default_addr.c dev_addr.c dev_addr_type.c
    ../../BLE_ATCMD/Source/Command/Common/Advertising/: adv_channel_map.c adv_data.c adv_interval.c adv_type.c disable_adv.c enable_adv.c scan_rsp.c
    ../../BLE_ATCMD/Source/Command/Common/Connect/: con_interval.c con_latency.c con_param.c con_timeout.c disconnect.c
    ../../BLE_ATCMD/Source/Command/Common/Connect_Other/: bonding_flag.c data_length.c init_bonding_info.c phy.c preferred_data_length.c preferred_mtu_size.c read_mtu_size.c read_phy.c restore_cccd.c rssi.c security.c
    ../../BLE_ATCMD/Source/Command/Common/Other/: all_param.c help.c reset.c role.c sleep.c wake_up.c add_accept_list.c remove_accept_list.c clear_filter_accept_list.c read_filter_accept_list_size.c
    ../../BLE_ATCMD/Source/Command/Common/Scanning/: disable_scan.c enable_scan.c scan_interval.c scan_type.c scan_window.c
    ../../BLE_ATCMD/Source/Command/Master/create_connect/: cancel_create_connect.c create_connect.c create_connect_interval.c create_connect_latency.c create_connect_timeout.c
    ../../BLE_ATCMD/Source/Command/Master/: exchange_mtu_size.c read.c read_cccd.c write.c write_cccd.c write_without_rsp.c
    ../../BLE_ATCMD/Source/Command/Slave/: gap_appearance.c gap_device_name.c gap_pre_con_param.c indicate.c notify.c read_rsp.c
  group CLI
    ../../CLI/: cli_cmd_atplus.c cli_cosole.c
software components: CMSIS:CORE 5.0.1

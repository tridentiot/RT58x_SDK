# Keil uVision project HOGP_Periph_Privacy_source.uvprojx, settings and files
target RT581_MPB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: HOGP_Periph_Privacy_source +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CHIP_TYPE=RT581, CHIP_VERSION=RT58X_MPB, RF_FW_INCLUDE_BLE=TRUE, RF_FW_INCLUDE_PCI=FALSE, RF_FW_INCLUDE_MULTI_2P4G=FALSE, SUPPORT_BLE
  c include: ..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\Library\RT58x\Peripheral\Include;..\..\..\..\..\..\Library\RT58x\PHY\include;..\..\..\..\..\..\Library\RT58x\include;..\..\..\..\..\..\Library\RT58x\PHY\rt569mp\include;..\..\..\..\..\..\Middleware\RF_FW_Control_Task\Include;..\..\..\..\..\..\Middleware\RUCI\include;..\..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middleware\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\..\Middleware\Portable\Utility\include;..\..\..\..\..\..\Middleware\Portable\System\Include;..\..\..\..\..\..\Middleware\Portable\bsp\Include;..\..\..\..\..\..\Middleware\MemoryMgmt\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Host\Include;..\..\..\..\..\..\Middleware\FOTA\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Host_Internal\Include;..\..\..\..\..\..\Middleware\BLE\Portable\Include;..\..\..\..\..\..\Middleware\BLE\HCI\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Service\BLE_Service_Common\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Service\GAPS\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Service\DIS\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Service\GATTS\Include;..\..\..\..\..\..\Middleware\BLE\BLE_Service\HIDS\Include;..\..\..\..\..\..\Middleware\Third_Party\uecc;..\BLE_App_Profile\Include;..\Config;..\Include;..\Keil
  asm define: USE_FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\HOGP_Periph_Privacy_source.sct
  group Application
    ../: main.c ble_app.c
    ../BLE_App_Profile/: ble_profile_def.c ble_profile_app.c
    ../config/: project_config.h
  group Startup
    ../../../../../../Library/RT58x/Device/: system_cm3_mcu.c
    ../../../../../../Library/RT58x/Device/ARM/: startup_cm3_mcu.s
  group Library
    ../../../../../../Library/RT58x/Peripheral/: gpio.c sysctrl.c sysfun.c timer.c dma.c uart_drv.c flashctl.c uart_retarget.c lpm.c sadc.c mp_sector.c
  group FreeRTOS
    ../../../../../../Middleware/Third_Party/FreeRTOS/Source/: tasks.c list.c queue.c timers.c
    ../../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middleware/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Config/: FreeRTOSConfig.h
  group System
    ../../../../../../Middleware/Portable/System/: sys_arch.c sys_memory.c sys_printf.c sys_taskdbg.c sys_timer.c
  group Utility
    ../../../../../../Middleware/Portable/Utility/: util.c util_list.c util_printf.c util_string.c util_log.c shell.c util_bda.c util_bstream.c util_fcs.c util_queue.c
  group BSP
    ../../../../../../Middleware/Portable/bsp/: bsp.c bsp_button.c bsp_console.c bsp_led.c bsp_uart.c
  group BLE
    ../../../../../../Middleware/BLE/BLE_Host/: ble_host_ref.c ble_cmd_advertising.c ble_cmd_att_gatt.c ble_cmd_common.c ble_cmd_gap.c ble_cmd_scan.c ble_cmd_security_manager.c ble_cmd_privacy.c
  group BLE_Task
    ../../../../../../Middleware/BLE/Portable/: task_ble_app.c task_host.c
    ../../../../../../Middleware/Prebuild/: lib_ble_hci_task.lib
  group BLE_Service
    ../../../../../../Middleware/BLE/BLE_Service/Ble_Service_Common/: ble_service_common.c
    ../../../../../../Middleware/BLE/BLE_Service/GAPS/: ble_service_gaps.c
    ../../../../../../Middleware/BLE/BLE_Service/GATTS/: ble_service_gatts.c
    ../../../../../../Middleware/BLE/BLE_Service/DIS/: ble_service_dis.c
    ../../../../../../Middleware/BLE/BLE_Service/HIDS/: ble_service_hids.c
  group BLE_Host
    ../../../../../../Middleware/BLE/BLE_Host_Internal/: att.c ble_advertising_api.c ble_api.c ble_api_handler.c ble_att_gatt_api.c ble_bonding_storage.c ble_common_api.c ble_event_app.c ble_event_module.c ble_gap_api.c ble_scan_api.c ble_security_manager_api.c host_management.c l2cap.c smp.c ble_privacy.c ble_memory.c ble_lesc.c
  group HCI
    ../../../../../../Middleware/BLE/HCI/Include/: hci_cmd.h
    ../../../../../../Middleware/BLE/HCI/: hci_cmd_vendor.c hci_cmd_controller.c hci_cmd_advertising.c hci_cmd_scan.c hci_cmd_security.c hci_cmd_connect.c hci_cmd_connect_cte.c hci_cmd_privacy.c hci_event.c
  group Phy
    ../../../../../../Middleware/Prebuild/: lib_rf_mcu.lib
    ../../../../../../Library/RT58x/PHY/: rf_tx_comp.c
    ../../../../../../Library/RT58x/PHY/rt569mp/: rt569mp_fw.c rt569mp_init.c
  group MemMgmt
    ../../../../../../Middleware/MemoryMgmt/: mem_mgmt.c
  group Version
    ../../../../../../Middleware/Version_Information/: version_api.c version_info.c
  group Sec
    ../../../../../../Middleware/Third_Party/uecc/: uECC.c
    ../../../../../../Middleware/BLE/BLE_Host_Internal/: sec_aes_cmac.c sec_aes.c
software components: CMSIS:CORE 5.0.1
